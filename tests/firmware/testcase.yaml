## tests/firmware/testcase.yaml
```yaml
tests:
  telemetry.firmware:
    platform_allow:
      - native_sim
    tags:
      - telemetry
      - firmware
```
